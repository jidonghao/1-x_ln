# Keil uVision project WiFiToCloud-M3.uvprojx, settings and files
target WiFiToCloud-M3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WiFiToCloud-M3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,NEWLAND_DEBUG,MAXUBUF=250,BAUD_RATE=115200
  c include: ..\source\app;..\source\boards;..\source\boards\hardware;..\source\boards\hardware\inc;..\source\boards\mcu\CM3;..\source\boards\mcu\STM32;..\source\boards\mcu\STM32\LIB\inc;..\source\peripherals;..\source\peripherals\inc;..\source\public;..\source\system;..\source\WiFiToCloud;..\source\WiFiToCloud\cloud
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../source/app/: main.c stm32App.c stm32f103_config.h
  group boards\hardware
    ../source/boards/hardware/src/: hal_buzzer.c hal_timer2.c hal_usart1.c hal_uart4.c
  group boards\cmsis
    ../source/boards/mcu/CM3/: core_cm3.c
    ../source/boards/mcu/STM32/: stm32f10x_it.c system_stm32f10x.c
    ../source/boards/mcu/STM32/STARTUP/: startup_stm32f10x_hd.s
  group boards\stm32
    ../source/boards/mcu/STM32/LIB/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group system
    ../source/system/: delay.c sys.c
  group readme
    ../: IO口定义说明.h 使用说明.h
  group WiFiToCloud
    ../source/WiFiToCloud/: WiFiToCloud.c HAL_WiFiToCloud.c CloudReference.h
