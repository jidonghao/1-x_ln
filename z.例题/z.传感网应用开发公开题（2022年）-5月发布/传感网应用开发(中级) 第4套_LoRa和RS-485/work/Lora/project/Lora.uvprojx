# Keil uVision project Lora.uvprojx, settings and files
target Lora (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lora +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA
  c include: ..\src\apps;..\src\boards\hardware;..\src\boards\hardware\cmsis;..\src\boards\mcu;..\src\boards\mcu\cmsis;..\src\boards\mcu\STM32L1xx_HAL_Driver\Inc;..\src\peripherals\hal_oled;..\src\radio;..\src\system;..\src\peripherals\hal_TempRh;..\src\radio\sx1276
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../src/apps/: main.c NS_Radio.c user_define.h
  group boards\hardware
    ../src/boards/hardware/: adc-board.c board.c gpio-board.c i2c-board.c iwdg-board.c rtc-board.c spi-board.c sx1276-board.c tim-board.c uart-board.c usart1-board.c
  group boards\hardware\cmsis
    ../src/boards/hardware/cmsis/: system_stm32l1xx.c startup_stm32l151xb.s
  group boards\mcu
    ../src/boards/mcu/: sysIrqHandlers.c utilities.c
  group boards\mcu\STM32L1xx_HAL_Driver
    ../src/boards/mcu/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group peripheral
    ../src/peripherals/hal_oled/: hal_oled.c
    ../src/peripherals/hal_TempRh/: hal_temHum.c
  group radio
    ../src/radio/sx1276/: sx1276.c
  group system
    ../src/system/: adc.c delay.c fifo.c gpio.c timer.c uart.c i2c.c
