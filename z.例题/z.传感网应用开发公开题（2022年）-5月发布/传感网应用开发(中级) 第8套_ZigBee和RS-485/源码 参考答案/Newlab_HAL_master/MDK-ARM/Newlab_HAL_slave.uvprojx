# Keil uVision project Newlab_HAL_slave.uvprojx, settings and files
target Newlab_HAL_master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Newlab_HAL_master +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Inc;../Bsp;../TOOL;..\Shell
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/Shell
    ../Shell/: usmart.c usmart_config.c usmart_str.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c iwdg.c tim.c usart.c wwdg.c stm32f1xx_it.c stm32f1xx_hal_msp.c flash.c app_master.c app_slave.c
    ../Src/TEST/: app_test.c app_test.h
  group Application/molloc
    ../Src/malloc/: malloc.c malloc.h
  group Application/modbusmaster
    ../Src/modbusmaster/: funcdisc_m.c holdregister_m.c inputregister_m.c mcheck.c protocol.c funcdisc_m.h holdregister_m.h inputregister_m.h mcheck.h protocol.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/485
    ../Drivers/485/: max485.c max485.h
  group tools
    ../TOOL/: kfifo.c sys.c
software components: CMSIS:CORE 4.3.0
