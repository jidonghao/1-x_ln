# IAR project test.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\jidonghao\jidonghao_16\z.例题\1.传感网应用开发（中级）师资培训训练题\ZigBee\CC2530_lib\basicrf; E:\jidonghao\jidonghao_16\z.例题\1.传感网应用开发（中级）师资培训训练题\ZigBee\CC2530_lib\board; E:\jidonghao\jidonghao_16\z.例题\1.传感网应用开发（中级）师资培训训练题\ZigBee\CC2530_lib\common; E:\jidonghao\jidonghao_16\z.例题\1.传感网应用开发（中级）师资培训训练题\ZigBee\CC2530_lib\mylib; E:\jidonghao\jidonghao_16\z.例题\1.传感网应用开发（中级）师资培训训练题\ZigBee\CC2530_lib\utils
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration EndDev (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: E:\18_wsa_1X\传感网应用开发（中级）第1套 师资培训训练题 公开资源\2. 传感网应用开发（中级） 公开训练题第1套 work\ZigBee\CC2530_lib\basicrf; E:\18_wsa_1X\传感网应用开发（中级）第1套 师资培训训练题 公开资源\2. 传感网应用开发（中级） 公开训练题第1套 work\ZigBee\CC2530_lib\board; E:\18_wsa_1X\传感网应用开发（中级）第1套 师资培训训练题 公开资源\2. 传感网应用开发（中级） 公开训练题第1套 work\ZigBee\CC2530_lib\common; E:\18_wsa_1X\传感网应用开发（中级）第1套 师资培训训练题 公开资源\2. 传感网应用开发（中级） 公开训练题第1套 work\ZigBee\CC2530_lib\mylib; E:\18_wsa_1X\传感网应用开发（中级）第1套 师资培训训练题 公开资源\2. 传感网应用开发（中级） 公开训练题第1套 work\ZigBee\CC2530_lib\utils
configuration GateDev (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  group app
    ./: EndDev.c GateDev.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.h basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_board.c hal_board.h hal_led.c hal_led.h
  group common
    ../CC2530_lib/common/: hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_digio.c hal_digio.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_rf_util.c hal_rf_util.h hal_sleep.c hal_sleep.h hal_timer_32k.c hal_timer_32k.h hal_uart.c hal_uart.h
  group mylib
    ../CC2530_lib/mylib/: TIMER.c TIMER.h UART_PRINT.c UART_PRINT.h
  group utils
    ../CC2530_lib/utils/: util.c util.h
