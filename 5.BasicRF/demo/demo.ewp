# IAR project demo.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: CC2530_DEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\jidonghao\jidonghao_16\5.BasicRF\sensor_drv; E:\jidonghao\jidonghao_16\5.BasicRF\CC2530_lib\basicrf; E:\jidonghao\jidonghao_16\5.BasicRF\CC2530_lib\board; E:\jidonghao\jidonghao_16\5.BasicRF\CC2530_lib\common; E:\jidonghao\jidonghao_16\5.BasicRF\CC2530_lib\mylib; E:\jidonghao\jidonghao_16\5.BasicRF\CC2530_lib\utils
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    project5.2/: sensor.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.h basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_adc.c hal_adc.h hal_board.c hal_board.h hal_led.c hal_led.h hal_pwm.c hal_pwm.h
  group common
    ../CC2530_lib/common/: hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_digio.c hal_digio.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_rf_util.c hal_rf_util.h hal_sleep.c hal_sleep.h hal_timer_32k.c hal_timer_32k.h hal_uart.c hal_uart.h hal_uart1.c hal_uart1.h
  group mylib
    ../CC2530_lib/mylib/: TIMER.c TIMER.h UART_PRINT.c UART_PRINT.h UART_SEND_RECV.c UART_SEND_RECV.h
  group sensor_drv
    ../sensor_drv/: get_adc.c get_adc.h get_swsensor.c get_swsensor.h sh10.c sh10.h
  group utils
    ../CC2530_lib/utils/: util.c util.h
