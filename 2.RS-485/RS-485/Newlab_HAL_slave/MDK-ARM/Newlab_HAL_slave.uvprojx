# Keil uVision project Newlab_HAL_slave.uvprojx, settings and files
target Newlab_HAL_slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Newlab_HAL_slave +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Bsp;../TOOL;..\Shell;..\Drivers\Sensor\Sht
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/Shell
    ../Shell/: usmart.c usmart_config.c usmart_str.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c iwdg.c tim.c usart.c wwdg.c stm32f1xx_it.c stm32f1xx_hal_msp.c flash.c app_slave.c
    ../Src/TEST/: app_test.c app_test.h
  group Application/Modbusslave
    ../Src/modbusslave/: funcdisc.c funcdisc.h holdregister.c holdregister.h inputregister.c inputregister.h mcheck.c mcheck.h protocol.c protocol.h
  group Application/molloc
    ../Src/malloc/: malloc.c malloc.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/485
    ../Drivers/485/: max485.c max485.h
  group Drivers/Sensor
    ../Drivers/Sensor/: app_sensor.c app_sensor.h InfraredSensor.c InfraredSensor.h
    ../Drivers/Sensor/Sht/: hal_i2c.c sht.c sht1x.c sht3x.c
  group tools
    ../TOOL/: kfifo.c sys.c
software components: CMSIS:CORE 4.3.0
